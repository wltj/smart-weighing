# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: MG_LOCALS, STM32F407xx, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: .;rt-thread\include;applications;.;board;board\CubeMX_Config\Inc;board\ports;libraries\HAL_Drivers;libraries\HAL_Drivers\config;libraries\HAL_Drivers\drv_flash;packages\button-v1.0.1;packages\ChineseFontLibrary-latest\inc;packages\cJSON-v1.0.2;packages\EasyFlash-v4.0.0\inc;packages\fal-v0.4.0\inc;packages\mongoose-v6.7;packages\nanopb-v1.0.0;packages\netutils-v1.1.0\ntp;packages\netutils-v1.1.0\tftp;packages\ota_downloader-latest;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;packages\qrcode-latest\inc;packages\SignalLed-latest\inc;packages\SignalLed-latest;packages\sx12xx-latest\inc;packages\sx12xx-latest\src\radio;packages\tcpserver-latest;packages\u8g2-cpp-latest;packages\u8g2-cpp-latest\port;packages\webclient-v2.1.2\inc;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;rt-thread\components\net\lwip-2.0.2\src;rt-thread\components\net\lwip-2.0.2\src\include;rt-thread\components\net\lwip-2.0.2\src\include\ipv4;rt-thread\components\net\lwip-2.0.2\src\arch\include;rt-thread\components\net\lwip-2.0.2\src\include\netif;rt-thread\components\net\lwip_dhcpd;rt-thread\components\net\netdev\include;rt-thread\components\net\sal_socket\include;rt-thread\components\net\sal_socket\include\socket;rt-thread\components\net\sal_socket\impl;rt-thread\components\net\sal_socket\include\dfs_net;rt-thread\components\net\sal_socket\include\dfs_net\sys_select;rt-thread\components\net\sal_socket\include\socket\sys_socket;rt-thread\components\utilities\ymodem;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\STM32F4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: LoRa_Cmd_Entry.c LoRa_Misc.c cmd_handle.c com_to_server_cmd_list.c com_to_server_thread.c crc.c easy_flash_used.c fifo.c gateway.c gateway.pb.c gui_thread.c lora.c main.c mqtt_thread.c tcp_client.c term_list.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: phy_reset.c spi_flash_init.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_qspi.c drv_eth.c drv_rtc.c drv_common.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
  group button_drive
    packages/button-v1.0.1/: button.c
  group Chinese_font_library
    packages/ChineseFontLibrary-latest/src/: cn_font.c cn_port.c mycc936.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group EasyFlash
    packages/EasyFlash-v4.0.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_fal_port.c ef_iap.c ef_log.c ef_utils.c
  group fal
    packages/fal-v0.4.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.4.0/samples/porting/: fal_flash_sfud_port.c
  group Mongoose
    packages/mongoose-v6.7/: mg_port.c mongoose.c
  group nanopb
    packages/nanopb-v1.0.0/: pb_common.c pb_decode.c pb_encode.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
    packages/netutils-v1.1.0/tftp/: tftp_port.c tftp_server.c
  group ota_downloader
    packages/ota_downloader-latest/src/: http_ota.c ymodem_ota.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group qrcode
    packages/qrcode-latest/src/: qrcode.c
  group SignalLed
    packages/SignalLed-latest/src/: signal_led.c
  group sx12xx
    packages/sx12xx-latest/src/: spi_lora_sx12xx.c
    packages/sx12xx-latest/ports/: sx12xx_device.c
    packages/sx12xx-latest/src/radio/: sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c radio.c
    packages/sx12xx-latest/samples/: sx12xx_sample.c
  group tcpserver
    packages/tcpserver-latest/: tcpserver.c tcpserver_sample.c
  group U8G2
    packages/u8g2-cpp-latest/src/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_d_a2printer.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1309.c u8x8_d_ssd1317.c u8x8_d_ssd1318.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st75256.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_stdio.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
    packages/u8g2-cpp-latest/port/: Print.cpp u8g2_port.cpp
    packages/u8g2-cpp-latest/examples/full_buffer/: FontUsage.cpp FPS.cpp GraphicsTest.cpp HelloWorld.cpp IconMenu.cpp PrintUTF8.cpp SelectionList.cpp U8g2Logo.cpp UpdateArea.cpp Weather.cpp
    packages/u8g2-cpp-latest/examples/page_buffer/: Chinese.cpp ClipWindow.cpp Clock.cpp ContrastTest.cpp Devanagari.cpp DirectAccess.cpp DrawLog.cpp ExtUTF8.cpp FlipMode_pb.cpp FPS_pb.cpp GraphicsTest_pb.cpp HelloWorld_pb.cpp IconMenu_pb.cpp Japanese.cpp Korean.cpp PowerSaveTest.cpp PrintHelloWorld.cpp ScrollingText.cpp SelectionList_pb.cpp Serial.cpp StateBufferLoop.cpp Terminal_pb.cpp U8g2Logo_pb.cpp UpdatePartly_pb.cpp Weather_pb.cpp XBM.cpp XORTest.cpp
    packages/u8g2-cpp-latest/examples/u8x8/: 16x16Font.cpp FlipMode.cpp GraphicsTest_8x8.cpp HelloWorld_8x8.cpp MessageBox_8x8.cpp Terminal_8x8.cpp
    packages/u8g2-cpp-latest/examples/games/: SpaceTrash.cpp TRex.cpp
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c alarm.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_w25qxx.c spi_flash_sfud.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group finsh
    rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip_dhcpd/: dhcp_server_raw.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    rt-thread/components/net/sal_socket/src/: sal_socket.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    rt-thread/components/utilities/ymodem/: ymodem.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_spi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_eth.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_nor.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c
