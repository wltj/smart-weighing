# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: rt-thread\components\net\sal_socket\include\socket\sys_socket; rt-thread\include; rt-thread\components\net\sal_socket\include\dfs_net\sys_select; packages\button-v1.0.1; packages\u8g2-c-latest\port; rt-thread\components\net\netdev\include; rt-thread\components\net\lwip-2.0.2\src; rt-thread\components\finsh; packages\pahomqtt-v1.1.0\MQTTClient-RT; packages\u8g2-c-latest; rt-thread\components\net\lwip-2.0.2\src\include; packages\sx12xx-latest\inc; board\CubeMX_Config\Inc; libraries\HAL_Drivers\config; libraries\HAL_Drivers; rt-thread\components\net\sal_socket\include\dfs_net; rt-thread\components\net\lwip-2.0.2\src\include\ipv4; rt-thread\libcpu\arm\common; rt-thread\components\net\lwip-2.0.2\src\arch\include; .; packages\sx12xx-latest\src\radio; rt-thread\components\drivers\include; board; packages\netutils-v1.1.0\ntp; libraries\HAL_Drivers\drv_flash; rt-thread\components\utilities\ymodem; rt-thread\components\net\lwip-2.0.2\src\include\netif; packages\SignalLed-latest; rt-thread\components\libc\compilers\dlib; packages\ota_downloader-latest; libraries\STM32F4xx_HAL\CMSIS\Include; libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc; board\ports; rt-thread\libcpu\arm\cortex-m4; applications; packages\EasyFlash-v4.0.0\inc; rt-thread\components\dfs\filesystems\devfs; packages\tcpserver-latest; libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include; packages\nanopb-v1.0.0; packages\fal-v0.4.0\inc; rt-thread\components\drivers\spi\sfud\inc; rt-thread\components\dfs\include; packages\webclient-v2.1.2\inc; packages\SignalLed-latest\inc; packages\cJSON-v1.0.2; rt-thread\components\libc\compilers\common; rt-thread\components\net\sal_socket\impl; packages\pahomqtt-v1.1.0\MQTTPacket\src; rt-thread\components\net\sal_socket\include; rt-thread\components\net\lwip_dhcpd; rt-thread\components\drivers\spi; rt-thread\components\net\sal_socket\include\socket
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: STM32F407xx; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; USE_HAL_DRIVER
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: cmd_handle.c com_to_server_cmd_list.c com_to_server_thread.c crc.c easy_flash_used.c gateway.c gateway.pb.c lora.c main.c mqtt_thread.c tcp_client.c term_list.c
  group button_drive
    packages/button-v1.0.1/: button.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/rtc/: alarm.c rtc.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c spi_flash_w25qxx.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group dlib
    rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Drivers
    board/: board.c
    libraries/HAL_Drivers/: drv_common.c drv_eth.c drv_gpio.c drv_qspi.c drv_rtc.c drv_soft_i2c.c drv_spi.c drv_usart.c
    libraries/HAL_Drivers/drv_flash/: drv_flash_f4.c
    board/ports/: phy_reset.c spi_flash_init.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
  group EasyFlash
    packages/EasyFlash-v4.0.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_fal_port.c ef_iap.c ef_log.c ef_utils.c
  group fal
    packages/fal-v0.4.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    packages/fal-v0.4.0/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
  group finsh
    rt-thread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip_dhcpd/: dhcp_server_raw.c
    rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
  group nanopb
    packages/nanopb-v1.0.0/: pb_common.c pb_decode.c pb_encode.c
  group netdev
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
  group ota_downloader
    packages/ota_downloader-latest/src/: http_ota.c ymodem_ota.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
  group SAL
    rt-thread/components/net/sal_socket/impl/: af_inet_lwip.c
    rt-thread/components/net/sal_socket/dfs_net/: dfs_net.c
    rt-thread/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal_socket/src/: sal_socket.c
  group SignalLed
    packages/SignalLed-latest/src/: signal_led.c
  group STM32_HAL
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_nor.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group sx12xx
    packages/sx12xx-latest/src/radio/: radio.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c sx1276.c
    packages/sx12xx-latest/src/: spi_lora_sx12xx.c
    packages/sx12xx-latest/ports/: sx12xx_device.c
    packages/sx12xx-latest/samples/: sx12xx_sample.c
  group tcpserver
    packages/tcpserver-latest/: tcpserver.c tcpserver_sample.c
  group U8G2
    packages/u8g2-c-latest/examples/: ssd1306_12864_sw_i2c_example.c
    packages/u8g2-c-latest/src/: u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_d_a2printer.c u8x8_d_il3820_296x128.c u8x8_d_ist3020.c u8x8_d_ks0108.c u8x8_d_lc7981.c u8x8_d_ld7032_60x32.c u8x8_d_ls013b7dh03.c u8x8_d_max7219.c u8x8_d_pcd8544_84x48.c u8x8_d_pcf8812.c u8x8_d_pcf8814_hx1230.c u8x8_d_sbn1661.c u8x8_d_sed1330.c u8x8_d_sh1106_64x32.c u8x8_d_sh1106_72x40.c u8x8_d_sh1107.c u8x8_d_sh1108.c u8x8_d_sh1122.c u8x8_d_ssd1305.c u8x8_d_ssd1306_128x32.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_ssd1306_48x64.c u8x8_d_ssd1306_64x32.c u8x8_d_ssd1306_64x48.c u8x8_d_ssd1306_96x16.c u8x8_d_ssd1309.c u8x8_d_ssd1317.c u8x8_d_ssd1322.c u8x8_d_ssd1325.c u8x8_d_ssd1326.c u8x8_d_ssd1327.c u8x8_d_ssd1329.c u8x8_d_ssd1606_172x72.c u8x8_d_ssd1607_200x200.c u8x8_d_st75256.c u8x8_d_st7565.c u8x8_d_st7567.c u8x8_d_st7586s_erc240160.c u8x8_d_st7586s_s028hn118a.c u8x8_d_st7588.c u8x8_d_st7920.c u8x8_d_stdio.c u8x8_d_t6963.c u8x8_d_uc1601.c u8x8_d_uc1604.c u8x8_d_uc1608.c u8x8_d_uc1610.c u8x8_d_uc1611.c u8x8_d_uc1617.c u8x8_d_uc1638.c u8x8_d_uc1701_dogs102.c u8x8_d_uc1701_mini12864.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u16toa.c u8x8_u8toa.c
    packages/u8g2-c-latest/port/: u8g2_port.c
  group Utilities
    rt-thread/components/utilities/ymodem/: ymodem.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
    packages/webclient-v2.1.2/samples/: webclient_get_sample.c webclient_post_sample.c
